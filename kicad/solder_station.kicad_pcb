# Repository Smeat/solder_station

File README:

The content of the "scad" folder is licensed under the CC-BY-SA-NC 4.0.
The rest, if not stated otherwise, is licensed under the GPLv3.

## KiCad design kicad/solder_station.kicad_pcb

Parts:
C1, C2, C3, C8, C10, C11, C14, C16, C18: 100nF; C_0603
C4, C5: 22pF; C_Disc_D3_P2.5
C6, C7: 10nF; C_0603
C9: 1mF; C_Radial_D13_L21_P5
C12, C17, C27: 10µF; C_0603
C13: CP; C_Radial_D6.3_L11.2_P2.5
C15, C24: 1mF; C_Radial_D6.3_L11.2_P2.5
C19, C20, C21, C22, C25, C26: 10µF 16V; C_0805
C23: 220µF; C_Radial_D6.3_L11.2_P2.5
D1, D2, D3, D4, D5: D; Diode_DO-35_SOD27_Horizontal_RM10
DS1: LCD-016N002L; Pin_Header_Straight_1x16
IC1: ATMEGA328-P; DIP-28_W7.62mm_LongPads
L1: 10µH; Choke_Horizontal_RM10mm
P1: CONN_01X05; TerminalBlock_Pheonix_PT-3.5mm_5pol
P2: CONN_01X02; TerminalBlock_Pheonix_PT-3.5mm_2pol
P3: Standby; Pin_Header_Straight_1x01
P4: UART; Pin_Header_Straight_1x04
P5: 12V_Out; Pin_Header_Angled_1x02
Q1: 2N7000; TO-92_Inline_Wide
Q2: IRF4905; TO-220_Neutral123_Vertical
R1: 10kΩ; Resistor_Horizontal_RM10mm
R2, R5, R12: 1kΩ; Resistor_Horizontal_RM10mm
R3: 10kΩ; R_0805
R4: 6.7kΩ; R_0805_HandSoldering
R6: 1kΩ; R_0805
R7: 100kΩ; R_0805
R8: 1kΩ; Resistor_Horizontal_RM7mm
R9: R; Resistor_Horizontal_RM10mm
R10: 300kΩ; Resistor_Horizontal_RM10mm
R11: 1MΩ; R_0805
R13, R15: 300Ω; R_0805
R14: 100Ω; R_0805
R16: 240Ω; R_0805
U1: LM2596_module; LM2596
U2: AD8572; SOIC-8_3.9x4.9mm_Pitch1.27mm
U3: EC11; Pin_Header_Straight_1x05
U4, U5: AMS1117; SOT-223
Y1: 16MHz; HC-49V

Connections:
+5V: C3.2, C18.1, C27.1, DS1.2 (VDD), IC1.7 (VCC), R1.1, R9.2, R14.1, U4.2 (Vout), U4.4 (Vout)
+5VA: C16.1, C17.1, D3.1 (K), L1.1, R16.1, U5.2 (Vout), U5.4 (Vout)
+12V: C23.1, D5.2 (A), P5.2, U1.3 (OUT+)
+12VA: C10.1, C11.1, C19.1, C20.1, C21.1, C22.1, C25.1, C26.1, D5.1 (K), U4.3 (Vin), U5.3 (Vin)
+24V: C15.1, C24.1, D4.2 (A), P2.1, Q2.3 (S), R5.1
/Button_connected: IC1.25 ((PCINT10/ADC2)PC2), P1.3
/Button_push: IC1.16 ((PCINT2/OC1B/~SS~)PB2), U3.4 (D)
/DTR: C8.1, P4.1
/Heater_PWM: IC1.15 ((PCINT1/OC1A)PB1), R2.2
/LCD_D4: DS1.11 (D4), IC1.6 ((PCINT20/XCK/T0)PD4)
/LCD_D5: DS1.12 (D5), IC1.11 ((PCINT21/OC0B/T1)PD5)
/LCD_D6: DS1.13 (D6), IC1.12 ((PCINT22/OC0A/AIN0)PD6)
/LCD_D7: DS1.14 (D7), IC1.13 ((PCINT23/AIN1)PD7)
/LCD_E: DS1.6 (E), IC1.5 ((PCINT19/OC2B/INT1)PD3)
/LCD_RS: DS1.4 (RS), IC1.4 ((PCINT18/INT0)PD2)
/LCD_RW: DS1.5 (R/W), IC1.14 ((PCINT0/CLKO/ICP1)PB0)
/RX: IC1.2 ((PCINT16/RXD)PD0), P4.2
/Rotary_A: IC1.19 ((PCINT5/SCK)PB5), U3.1 (A)
/Rotary_B: IC1.17 ((PCINT3/OC2A/MOSI)PB3), U3.3 (B)
/TX: IC1.3 ((PCINT17/TXD)PD1), P4.3
/Temp_sense: C7.1, IC1.23 ((PCINT8/ADC0)PC0), R8.1
/Tip: P1.2, R11.2
AVcc: C1.2, C13.1, C14.2, IC1.20 (AVCC), L1.2, R10.2, U2.8
GND: C1.1, C2.2, C3.1, C4.1, C5.1, C6.2, C7.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.1, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, D1.2 (A), D2.1 (K), DS1.1 (VSS), DS1.3 (VO), DS1.16 (LED-), IC1.8 (GND), IC1.22 (GND), P1.1, P1.5, P2.2, P4.4, P5.1, Q1.1 (D), R3.2, R6.2, R11.1, R13.2, R15.2, U1.2 (IN-), U1.4 (OUT-), U2.4, U3.2 (C), U3.5 (E)
unnamed: C2.1, IC1.21 (AREF)
unnamed: C4.2, IC1.9 ((PCINT6/XTAL1/TOSC1)PB6), Y1.1
unnamed: C5.2, IC1.10 ((PCINT7/XTAL2/TOSC2)PB7), Y1.2
unnamed: C8.2, IC1.1 ((PCINT14/~RESET~)PC6), R1.2
unnamed: C9.1, D4.1 (K), U1.1 (IN+)
unnamed: C12.1, D3.2 (A), R15.1, R16.2, U5.1 (ADJ)
unnamed: DS1.15 (LED+), R9.1
unnamed: IC1.26 ((PCINT11/ADC3)PC3), P3.1
unnamed: Q1.2 (G), R2.1, R3.1
unnamed: Q1.3 (S), R12.2
unnamed: Q2.1 (G), R5.2, R12.1
unnamed: R6.1, R7.2, U2.2
unnamed: R7.1, R8.2, U2.1
unnamed: R13.1, R14.2, U4.1 (ADJ)

Notes on the sheet:
Pin 3 and 5 are shorted by connector
5V Analog supply
5V Supply
12V Supply
Power Connections
Kicad stuff
Microcontroller
Connectors
LCD
Fet
Temperature sense

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
Board: 2 copper layers, 63.8 x 64.0 mm, 67 parts (32 on the bottom side), 40 nets.

Other parts of the board:
Hole1, Hole1#2, Hole3: MountingHole_3mm

## Code that names these connections

File Firmware/src/constants.h:

/*
 * constants.h
 *
 *  Created on: 22.01.2016
 *      Author: kevin
 */

#include <avr/pgmspace.h>

#ifndef CONSTANTS_H_
#define CONSTANTS_H_

#define CHARACTER_THERMOMETER 0x01
#define CHARACTER_DEGREE 0x02
#define CHARACTER_KP 0x03
#define CHARACTER_KI 0x04
#define CHARACTER_KD 0x05
#define CHARACTER_PLAY 0x06
#define CHARACTER_PAUSE 0x07

#define HEATER_WAIT_DELAY 5

#define DEFAULT_KP 10
#define DEFAULT_KI 1.2
#define DEFAULT_KD 9

#define DEFAULT_FACTOR 0.48f
#define DEFAULT_CONSTANT 19

#define EEPROM_DEF 0xFF

#define MENU_MAIN 0
#define MENU_CONNECTED 1
#define MENU_OPTIONS_SELECT 2

#define MENU_OPTIONS_PID 3
#define MENU_OPTIONS_CALIBRATE 4
#define MENU_OPTIONS_RESET 5
#define MENU_OPTIONS_TEMP 6

#define NUM_MENU_OPTIONS 4

const char* option_menus[] = {"PID", "Calibration", "Temperatures", "Reset default"};

#define MENU_OPTIONS_PID_LAST_ITEM 3
#define MENU_OPTIONS_CALIBRATE_LAST_ITEM 2

#define MAX_PWM 1023

const float updateTime = 0.2f;

// Buttons
#define ROTATE_PIN PINB
#define ROTATE_PORT PORTB
#define ROTATE_DDR DDRB
#define ROTATE_A_PIN PB5
#define ROTATE_B_PIN PB3
#define ROTATE_C_PIN PB2

#define BUTTON_STANDBY_DDR DDRC
#define BUTTON_STANDBY_PIN_REGISTER PINC
#define BUTTON_STANDBY_PIN PC3
#define BUTTON_STANDBY_PORT PORTC

#define BUTTON_CONNECTED_DDR DDRC
#define BUTTON_CONNECTED_PIN_REGISTER PINC
#define BUTTON_CONNECTED_PIN PC2
#define BUTTON_CONNECTED_PORT PORTC

#define LCD_SUPPORT

#define UART_DEBUG1
#ifdef UART_DEBUG
//#define UART_DEBUG_PID
#define UART_DEBUG_INPUT
#define UART_DEBUG_TEMP1
#endif

#ifdef LCD_SUPPORT
//from marlin https://github.com/MarlinFirmware/Marlin
static const PROGMEM unsigned char char_thermometer[] =
{
		0b00100,
		0b01010,
		0b01010,
		0b01010,
		0b01010,
		0b10001,
		0b10001,
		0b01110

};

static const PROGMEM unsigned char char_degree[] =
{
		0b01100,
		0b10010,
		0b10010,
		0b01100,
		0b00000,
		0b00000,
		0b00000,
		0b00000
};

static const PROGMEM unsigned char char_ki[] =
{
		0b10010,
		0b10100,
		0b11000,
		0b10101,
		0b10010,
		0b00001,
		0b00001,
		0b00001
};

static const PROGMEM unsigned char char_kp[] =
{
	0b10010,
	0b10100,
	0b11000,
	0b10100,
	0b10010,
	0b01100,
	0b01100,
	0b01000
};

static const PROGMEM unsigned char char_kd[] =
{
	0b10010,
	0b10100,
	0b11000,
	0b10100,
	0b10010,
	0b01100,
	0b01010,
	0b01100
};

static const PROGMEM unsigned char char_play[] =
{
	0b11000,
	0b10100,
	0b10010,
	0b10001,
	0b10010,
	0b10100,
	0b11000,
	0b00000
};

static const PROGMEM  unsigned char char_pause[] =
{
	0b00000,
	0b11011,
	0b11011,
	0b11011,
	0b11011,
	0b11011,
	0b11011,
	0b00000
};

#endif

#endif /* CONSTANTS_H_ */

## Commit log

2015-12-11 First commit.
2015-12-12 Update.
2016-01-17 README.
2016-01-17 First version of the 3D model.
2016-01-17 Update schematic.
2016-01-17 Kicad file update.
2016-01-17 Add .gitignore.
2016-01-17 Update make_box script and add 3D files.
2016-01-17 Update Box. New Option: top_slots and font_layers.
2016-01-17 Add attributes file.
2016-01-17 New structure for configs.
2016-01-21 Update kicad schematics (still incomplete).
2016-01-23 Update Schematics.
2016-01-27 [Kicad] Update Schematics. Use local labels.
2016-01-27 [Kicad] First (bad) version of the PCB.
2016-01-27 [Git] Add some binary definitions in .gitattributes.
2016-01-27 [Firmware] First version of Firmware (still untested and not very good).
2016-01-27 [Kicad] Fix bug in schematics (VGS too high). Still not sure if it is okay this way.
2016-02-06 [Kicad] Update schematics. Using ad8551.
2016-02-06 [Doc] Add picture of the control board.
2016-02-06 [Firmware] Update firmware.
2016-02-07 [Doc] Add UI graph.
2016-02-07 [Firmware] Add new calibration menu.
2016-02-07 [Doc] Delete duplicate picture (old location)
2016-02-07 [Scad] Add pcb mounting holes.
2016-02-07 [Scad] Add fx-9501 handle for future use.
2016-02-08 [Scad] Add screw holes.
2016-02-08 [Scad] Remove gcode file.
2016-02-08 [Firmware] Add options menu for temperatures.
2016-02-23 [Kicad] Update schematics. Use smd capacitors. Add big capacitor for 24V input. Add first approach to fix #1 (still incomplete. Needs testing).
2016-03-02 [Kicad] Use more capacitors and smd parts
2016-03-02 [Kicad] Update (forgot to save).
2016-03-02 [Kicad] Update schematics pdf.
2016-03-02 [Kicad] Add resistor values for voltage regulators.
2016-03-03 [Kicad] Add a few more capacitors.
2016-03-03 [Kicad] Move references.
2016-11-06 [Kicad] Small updates
